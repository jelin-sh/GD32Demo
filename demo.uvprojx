# Keil uVision project demo.uvprojx, settings and files
target DefualtTarget (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F307VE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: .\Application;.\Application\Demo1_GPIO;.\Application\Demo2_USART;.\Core;.\Core\CMSIS;.\FramewareLibrary\Include;.\Framework;.\Framework\GPIO;.\Framework\USART;.\Application\Demo4_WWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ./Core/CMSIS/: system_gd32f30x.c startup_gd32f30x_cl.s
    ./Core/: main.c gd32f30x_it.c systick.c
  group Application
    ./Application/Demo1_GPIO/: demo1_GPIO.c
    ./Application/Demo2_USART/: Demo2_USART.c
    ./Application/Demo4_WWDG/: Demo4_WWDG.c
  group Framework
    ./Framework/GPIO/: Port.c
    ./Framework/USART/: usart.c
  group Frameware
    ./FramewareLibrary/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
